# Keil uVision project Project_IAP.uvproj, settings and files
target IAP (ARM-ADS)
  device: HT32F1654 Holtek
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0000FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1654_DVB
  c include: ..\;..\..\library\HT32F1653_54_Driver\inc;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F1653_54\Include;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\Src_IAP;..\Board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_ht32f165x_it.c iap_ht32_usbd_descriptor.c iap_ht32_usbd_class.c iap_handler.c iap_buffer.c iap_crc16.c _HT32_USBBufCheck.lib
  group bord
    ../Board/: spi_flash_mx25l12835f.c
  group MDK-ARM
    ./: startup_ht32f165x_iap.s
  group USBD_Library
    ../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Config
    ../Src_IAP/: ht32f1653_54_conf.h ht32f165x_usbdconf.h
    ./: HT32F165x_DebugSupport.ini
  group Library
    ../../library/HT32F1653_54_Driver/src/: ht32_cm3_misc.c ht32f1653_54_adc.c ht32f1653_54_bftm.c ht32f1653_54_ckcu.c ht32f1653_54_cmp.c ht32f1653_54_crc.c ht32f1653_54_ebi.c ht32f1653_54_exti.c ht32f1653_54_flash.c ht32f1653_54_gpio.c ht32f1653_54_gptm.c ht32f1653_54_i2c.c ht32f1653_54_i2s.c ht32f1653_54_mctm.c ht32f1653_54_pdma.c ht32f1653_54_pwrcu.c ht32f1653_54_rstcu.c ht32f1653_54_rtc.c ht32f1653_54_sci.c ht32f1653_54_spi.c ht32f1653_54_usart.c ht32f1653_54_usbd.c ht32f1653_54_wdt.c
  group Retarget
    ../../library/HT32F1653_54_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: ebi_lcd.c i2c_eeprom.c
  group CMSIS
    ../Src_IAP/: iap_system_ht32f165x.c
  group Doc
    ../: readme.txt
