# IAR project Project_AP.ewp, settings and files
configuration AP (ARM, debug)
  General.OGChipSelectEditMenu: HT32F1654 Holtek HT32F1654
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F1654_DVB
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F1653_54_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F1653_54\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities; ..\Src_AP
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AP.bin
  ILINK.IlinkOutputFile: AP.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src_AP/: system_ht32f165x.c
  group Config
    ./: ht32_op.c
    ../Src_AP/: ht32f1653_54_conf.h ht32f165x_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f165x.s
  group Library
    ../../../../library/HT32F1653_54_Driver/src/: ht32_cm3_misc.c ht32f1653_54_adc.c ht32f1653_54_bftm.c ht32f1653_54_ckcu.c ht32f1653_54_cmp.c ht32f1653_54_crc.c ht32f1653_54_ebi.c ht32f1653_54_exti.c ht32f1653_54_flash.c ht32f1653_54_gpio.c ht32f1653_54_gptm.c ht32f1653_54_i2c.c ht32f1653_54_i2s.c ht32f1653_54_mctm.c ht32f1653_54_pdma.c ht32f1653_54_pwrcu.c ht32f1653_54_rstcu.c ht32f1653_54_rtc.c ht32f1653_54_sci.c ht32f1653_54_spi.c ht32f1653_54_usart.c ht32f1653_54_usbd.c ht32f1653_54_wdt.c
  group Retarget
    ../../../../library/HT32F1653_54_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ../Src_AP/: ht32f165x_it.c main.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
